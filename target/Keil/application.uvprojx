# Keil uVision project application.uvprojx, settings and files
target Internal flash and NOR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: application +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: ST STM32F429xx USE_OS_SYSTICK USE_BPP=16 USE_STDPERIPH_DRIVER USE_FLOATING_POINT USE_OS_SYSTICK USE_IOEXPANDER
  c include: ..\..\gui\include;..\..\platform\os;..\..\generated\fonts\include;..\..\generated\images\include;..\..\generated\texts\include;..\..\generated\gui_generated\include;../../touchgfx/framework/include;../bsp/include\platform\core\arm\cortex-m\CMSIS;../bsp/include\platform\hal\ST\mcu\stm32f4cube;../bsp/include/platform/stm32f4cube/CMSIS;..\bsp\include;..\bsp\include\bsp;..\bsp\source\vendor\STM324x9I_EVAL;..\bsp\include\platform\stm32f4cube\STM32F4xx_HAL_Driver;..\os\FreeRTOS7.6.0\Source\include;..\os\FreeRTOS7.6.0\;..\os\FreeRTOS7.6.0\Source\portable\RVDS\ARM_CM4F;..\..\User
  asm include: ..\os
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../: main.cpp
    ../bsp/source/platform/stm32f4cube/Keil/: startup_stm32f429xx.s
  group TouchGFXHAL
    ../bsp/source/platform/cortex-m/: CortexMMCUInstrumentation.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: STM324x9IButtonController.cpp STM324x9ITouchController.cpp
    ../bsp/source/platform/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL.cpp
  group HAL
    ../bsp/source/vendor/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_lcd.c stm324x9i_eval_nor.c stm324x9i_eval_sdram.c stm324x9i_eval_ts.c stm324x9i_eval_io.c
    ../bsp/source/vendor/Components/stmpe811/: stmpe811.c
    ../bsp/source/platform/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_uart.c
    ../bsp/source/platform/stm32f4cube/CMSIS/: system_stm32f4xx.c
    ../bsp/source/vendor/Components/stmpe1600/: stmpe1600.c
    ../bsp/source/vendor/Components/ts3510/: ts3510.c
    ../bsp/source/vendor/Components/exc7200/: exc7200.c
  group OS
    ../os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/common/: frontendapplication.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group generated
    ../../generated/fonts/src/: applicationfontprovider.cpp fontgetters.cpp Font_Asap_Regular_80_4bpp.cpp Kerning_Asap_Regular_80_4bpp.cpp Table_Asap_Regular_80_4bpp.cpp
    ../../generated/images/src/: bitmapdatabase.cpp bg.cpp counter_box.cpp down_btn.cpp down_btn_disabled.cpp down_btn_pressed.cpp up_btn.cpp up_btn_disabled.cpp up_btn_pressed.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/main_screen/: MainViewBase.cpp
    ../../generated/images/src/__designer/: blue_slider_horizontal_large_indicators_slider_round_nob.cpp blue_slider_horizontal_large_slider_round_back.cpp blue_slider_horizontal_large_slider_round_fill.cpp blue_togglebars_toggle_round_large_button_off.cpp blue_togglebars_toggle_round_large_button_on.cpp blue_buttons_round_icon_button.cpp blue_buttons_round_icon_button_pressed.cpp blue_buttons_round_small.cpp blue_buttons_round_small_pressed.cpp blue_icons_add_new_32.cpp blue_slider_vertical_medium_indicators_slider3_vertical_round_nob.cpp blue_slider_vertical_medium_slider3_vertical_round_back.cpp blue_slider_vertical_medium_slider3_vertical_round_fill.cpp blue_togglebars_toggle_re_small_button_off.cpp blue_togglebars_toggle_re_small_button_on.cpp
  group User
    ../../User/: Bsp.c
    ../bsp/source/vendor/Components/GT9157/: GT9157.c
software components: CMSIS:CORE 5.0.2
